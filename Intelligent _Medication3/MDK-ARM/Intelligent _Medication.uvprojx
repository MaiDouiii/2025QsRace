# Keil uVision project Intelligent _Medication.uvprojx, settings and files
target Intelligent _Medication (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Intelligent _Medication +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../APP/LCD;../APP/TOUCH;../APP/delay;../APP/LVGL/GUI;../APP/LVGL/GUI/lvgl;../APP/LVGL/GUI/lvgl/src;../APP/LVGL/GUI/lvgl/examples/porting;../APP/KEY;../APP;../APP/SDcard;../APP/MOTOR;../APP/Ring_Buff;../APP/ui_code;../APP/my_task;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../APP/AT24C02;../APP/DHT11;../APP/esp8266;../APP/AS5600
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c fsmc.c rtc.c sdio.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group APP
    ../APP/delay/: delay.c
    ../APP/LCD/: lcd.c
    ../APP/TOUCH/: ctiic.c gt9xxx.c touch.c
    ../APP/KEY/: key.c
    ../APP/: bsp_system.h
    ../APP/MOTOR/: motor.c
    ../APP/Ring_Buff/: driver_ring.c
    ../APP/AT24C02/: iic.c
    ../APP/DHT11/: dht11.c
    ../APP/esp8266/: esp8266.c DataHandle.c cJSON.c
    ../APP/AS5600/: my_iic.c
  group lvgl/examp/porting
    ../APP/LVGL/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group lvgl/src/core
    ../APP/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/src/draw
    ../APP/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../APP/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl/src/extra
    ../APP/LVGL/GUI/lvgl/src/extra/: lv_extra.c
    ../APP/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../APP/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../APP/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../APP/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../APP/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../APP/LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../APP/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../APP/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../APP/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../APP/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../APP/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../APP/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../APP/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../APP/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../APP/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../APP/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../APP/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../APP/LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../APP/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../APP/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../APP/LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../APP/LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../APP/LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../APP/LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../APP/LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../APP/LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../APP/LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../APP/LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../APP/LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../APP/LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../APP/LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../APP/LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../APP/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../APP/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
  group lvgl/src/font
    ../APP/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl/src/gpu
    ../APP/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../APP/LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
  group lvgl/src/hal
    ../APP/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/src/misc
    ../APP/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/src/widgets
    ../APP/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group my_task
    ../APP/my_task/: my_task_init.c my_lvgl_task.c my_key_task.c my_rtc_task.c my_motor_task.c my_uart_task.c my_check_task.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group ui_code
    ../APP/ui_code/: ui.c ui_helpers.c
    ../APP/ui_code/screens/: ui_Content.c ui_Log.c ui_Main.c ui_Setting.c ui_Show.c ui_WIFI.c
    ../APP/ui_code/fonts/: ui_font_Font1.c
    ../APP/ui_code/components/: ui_comp_hook.c
  group ui_img
    ../APP/ui_code/images/: ui_img_67163344.c ui_img_163563252.c ui_img_204610073.c ui_img_299487825.c ui_img_537269857.c ui_img_719842935.c ui_img_944254084.c ui_img_1609717271.c ui_img_1638619773.c ui_img_1649269564.c ui_img_1761980177.c ui_img_2088777935.c ui_img_2141527451.c ui_img_contents_png.c ui_img_sdcard_png.c ui_img_wifi_png.c
software components: CMSIS:CORE 6.1.0
